# IAR project avr32_applications_can-lin-loopbacks-demo_uc3c_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCIncludePath2: ..\..\..\..\drivers\tc; ..\..\..\..\drivers\ebi\smc; ..\..\..\..\drivers\cpu\cycle_counter; ..\..\conf; ..\..\..\..\..\common\boards; ..\..\..\..\drivers\pm; ..\..\..\..\services\network\lin; ..\..\..\..\drivers\usart; ..\..\..\..\drivers\intc; ..\..\..\..\drivers\canif; ..\..\..\..\..\common\utils; ..\..\..\..\components\display\et024006dhu; ..\..\..\..\utils; ..\..\..\..\components\touch\at42qt1060; ..\..\..\..\utils\preprocessor; ..\..\..\..\drivers\scif; ..\..\..\..\drivers\flashc; ..\..\..\..\utils\debug; ..\..\..\..\boards\uc3c_ek; ..\..\..\..\boards; ..\..\..\..\drivers\twim; ..\..\..\..\services\network\can; ..\..\..\..\services\basic\delay; ..\..\..\..\utils\libs\dsplib\include; ..\..\..\..\drivers\adcifa; ..\..\..\..\drivers\gpio; ..\..\..\..\drivers\pdca
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\utils\linker_scripts\at32uc3c\0256c\iar\lnkuc3c0256c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group (top)
    ../../../../utils/libs/dsplib/at32ucr3/iar/: libdsp-at32ucr3-dspspeed_opt.r82
    ../../../../drivers/pm/: power_clocks_lib.c pm_uc3c.c
    ../../../../drivers/pdca/: pdca.c
    ../../: can_task.c main.c lin_task.c controller.c background_image.c gui.c
    ../../../../services/basic/delay/: delay.c
    ../../../../drivers/canif/: canif.c
    ../../../../drivers/ebi/smc/: smc.c
    ../../../../drivers/intc/: intc.c exception.s82
    ../../../../drivers/tc/: tc.c
    ../../../../drivers/scif/: scif_uc3c.c
    ../../../../services/network/can/: can.c
    ../../../../services/network/lin/: lin.c
    ../../../../drivers/usart/: usart.c
    ../../../../drivers/adcifa/: adcifa.c
    ../../../../drivers/gpio/: gpio.c
    ../../../../drivers/twim/: twim.c
    ../../../../components/display/et024006dhu/: et024006dhu.c
    ../../../../utils/debug/: print_funcs.c
    ../../../../drivers/flashc/: flashc.c
    ../../../../components/touch/at42qt1060/: at42qt1060.c
    ../../../../utils/startup/: trampoline_uc3.s82
