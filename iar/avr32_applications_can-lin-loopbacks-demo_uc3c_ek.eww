<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\avr32_applications_can-lin-loopbacks-demo_uc3c_ek.ewp</path>
  </project>
  <batchBuild/>
</workspace>
